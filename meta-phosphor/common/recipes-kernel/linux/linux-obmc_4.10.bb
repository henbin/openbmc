KBRANCH ?= "dev-4.10"
LINUX_VERSION ?= "4.10.17"

SRCREV="857b2befa4caa38513db24f41ca8a38a6bea908e"

require linux-obmc.inc
