FILESEXTRAPATHS_prepend_tiogapass := "${THISDIR}/${PN}:"
SRC_URI_append_tiogapass = " file://0001-Enable_Port80_Display.patch"
