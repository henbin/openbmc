SUMMARY = "tiogapass board wiring"
DESCRIPTION = "Board wiring information for the tiogapass system."
PR = "r1"

SKELETON_URI ?= "git://github.com/henbin/skeleton"
SRCREV ?= "0557d9ba7e62a949aaf8dce36e5b72e27fdf43b5"
inherit config-in-skeleton
